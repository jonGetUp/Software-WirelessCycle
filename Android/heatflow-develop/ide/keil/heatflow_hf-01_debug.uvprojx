# Keil uVision project heatflow_hf-01_debug.uvprojx, settings and files
target nRF52832_XXAA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: heatflow +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HEI DEBUG_NRF_USER DEBUG BOARD_HF_10 NRF52 NRF52832_XXAA NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT BLE_STACK_SUPPORT_REQD CONFIG_NFCT_PINS_AS_GPIOS FLOAT_ABI_HARD NRFX_SWI0_DISABLED xCONFIG_GPIO_AS_PINRESET
  c misc: --reduce_paths
  c include: ..\..;..\..\application;..\..\application\config;..\..\core;..\..\library\mcu\common\nrf5;..\..\library\mcu\common\nrf5\hal;..\..\library\mdw;..\..\library\mdw\sensor;..\..\library\mdw-nrf\common;..\..\library\mdw-nrf\common\battery;..\..\library\mdw-nrf\common\ble;..\..\library\mdw-nrf\common\button;..\..\library\mdw-nrf\common\core;..\..\library\mdw-nrf\common\flash;..\..\library\mdw-nrf\common\gpio;..\..\library\mdw-nrf\common\pool;..\..\library\mdw-nrf\common\timer;..\..\library\mdw-nrf\partners;..\..\library\mdw-nrf\partners\ble\services\hevs;..\..\library\platform\board;..\..\library\platform\heatflow_10;..\..\library\platform\heatflow_10\config;..\..\library\sdk-patch;..\..\library\xf;..\..\library\nRF5-SDK\components;..\..\library\nRF5-SDK\components\ble;..\..\library\nRF5-SDK\components\ble\ble_advertising;..\..\library\nRF5-SDK\components\ble\ble_db_discovery;..\..\library\nRF5-SDK\components\ble\ble_services;..\..\library\nRF5-SDK\components\ble\ble_services\ble_bas;..\..\library\nRF5-SDK\components\ble\ble_services\ble_dfu;..\..\library\nRF5-SDK\components\ble\ble_services\ble_dis;..\..\library\nRF5-SDK\components\ble\common;..\..\library\nRF5-SDK\components\ble\nrf_ble_gatt;..\..\library\nRF5-SDK\components\ble\nrf_ble_qwr;..\..\library\nRF5-SDK\components\ble\peer_manager;..\..\library\nRF5-SDK\components\libraries;..\..\library\nRF5-SDK\components\libraries\atomic;..\..\library\nRF5-SDK\components\libraries\atomic_fifo;..\..\library\nRF5-SDK\components\libraries\atomic_flags;..\..\library\nRF5-SDK\components\libraries\balloc;..\..\library\nRF5-SDK\components\libraries\bootloader;..\..\library\nRF5-SDK\components\libraries\bootloader\ble_dfu;..\..\library\nRF5-SDK\components\libraries\bootloader\dfu;..\..\library\nRF5-SDK\components\libraries\crc16;..\..\library\nRF5-SDK\components\libraries\delay;..\..\library\nRF5-SDK\components\libraries\experimental_section_vars;..\..\library\nRF5-SDK\components\libraries\fds;..\..\library\nRF5-SDK\components\libraries\fifo;..\..\library\nRF5-SDK\components\libraries\fstorage;..\..\library\nRF5-SDK\components\libraries\gpiote;..\..\library\nRF5-SDK\components\libraries\hardfault;..\..\library\nRF5-SDK\components\libraries\log;..\..\library\nRF5-SDK\components\libraries\log\src;..\..\library\nRF5-SDK\components\libraries\memobj;..\..\library\nRF5-SDK\components\libraries\mutex;..\..\library\nRF5-SDK\components\libraries\pwr_mgmt;..\..\library\nRF5-SDK\components\libraries\queue;..\..\library\nRF5-SDK\components\libraries\scheduler;..\..\library\nRF5-SDK\components\libraries\strerror;..\..\library\nRF5-SDK\components\libraries\svc;..\..\library\nRF5-SDK\components\libraries\timer;..\..\library\nRF5-SDK\components\libraries\util;..\..\library\nRF5-SDK\components\softdevice;..\..\library\nRF5-SDK\components\softdevice\common;..\..\library\nRF5-SDK\components\softdevice\s132;..\..\library\nRF5-SDK\components\softdevice\s132\headers;..\..\library\nRF5-SDK\components\softdevice\s132\headers\nrf52;..\..\library\nRF5-SDK\components\toolchain;..\..\library\nRF5-SDK\external\fprintf;..\..\library\nRF5-SDK\external\segger_rtt;..\..\library\nRF5-SDK\integration;..\..\library\nRF5-SDK\integration\nrfx;..\..\library\nRF5-SDK\modules\nrfx;..\..\library\nRF5-SDK\modules\nrfx\drivers;..\..\library\nRF5-SDK\modules\nrfx\drivers\include;..\..\library\nRF5-SDK\modules\nrfx\drivers\src;..\..\library\nRF5-SDK\modules\nrfx\hal;..\..\library\nRF5-SDK\modules\nrfx\mdk;.
  asm define: HEI DEBUG_NRF_USER BOARD_HF_10 NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT BLE_STACK_SUPPORT_REQD NRF_DFU_SVCI_ENABLED NRF_DFU_TRANSPORT_BLE=1 CONFIG_NFCT_PINS_AS_GPIOS FLOAT_ABI_HARD NRFX_SWI0_DISABLED SWI_DISABLE0
  asm misc: --cpreproc_opts=-DDEBUG_NRF_USER,-DBOARD_HF_10,-DNRF52,-DNRF52832_XXAA,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSOFTDEVICE_PRESENT,-DBLE_STACK_SUPPORT_REQD,-DCONFIG_NFCT_PINS_AS_GPIOS,-DFLOAT_ABI_HARD,-DNRFX_SWI0_DISABLED,-DSWI_DISABLE0
  asm include: ..;..\..\application;..\..\application\config;..\..\core;..\..\library\mcu\common\nrf5;..\..\library\mcu\common\nrf5\hal;..\..\library\mcu\partners\nrf5;..\..\library\mcu\partners\nrf5\hal;..\..\library\mdw;..\..\library\mdw\charger;..\..\library\mdw\charger\interface;..\..\library\mdw\interface;..\..\library\mdw\notification;..\..\library\mdw\notification\config;..\..\library\mdw\sensor;..\..\library\mdw\sensor\adxl362;..\..\library\mdw\sensor\lis2dw12;..\..\library\mdw-nrf\common;..\..\library\mdw-nrf\common\battery;..\..\library\mdw-nrf\common\ble;..\..\library\mdw-nrf\common\button;..\..\library\mdw-nrf\common\communication;..\..\library\mdw-nrf\common\communication\i2c;..\..\library\mdw-nrf\common\communication\i2c\interface;..\..\library\mdw-nrf\common\communication\spim;..\..\library\mdw-nrf\common\core;..\..\library\mdw-nrf\common\flash;..\..\library\mdw-nrf\common\gpio;..\..\library\mdw-nrf\common\pool;..\..\library\mdw-nrf\common\timer;..\..\library\mdw-nrf\partners;..\..\library\mdw-nrf\partners\ble\services;..\..\library\mdw-nrf\partners\ble\services\soprod;..\..\library\mdw-nrf\partners\ble\services\hei;..\..\library\platform\board;..\..\library\platform\pca10040;..\..\library\platform\pca10040\config;..\..\library\sdk-patch;..\..\library\xf;..\..\library\nRF5-SDK\components;..\..\library\nRF5-SDK\components\ble;..\..\library\nRF5-SDK\components\ble\ble_advertising;..\..\library\nRF5-SDK\components\ble\ble_db_discovery;..\..\library\nRF5-SDK\components\ble\ble_services;..\..\library\nRF5-SDK\components\ble\ble_services\ble_ancs_c;..\..\library\nRF5-SDK\components\ble\ble_services\ble_bas;..\..\library\nRF5-SDK\components\ble\ble_services\ble_dfu;..\..\library\nRF5-SDK\components\ble\ble_services\ble_dis;..\..\library\nRF5-SDK\components\ble\common;..\..\library\nRF5-SDK\components\ble\nrf_ble_gatt;..\..\library\nRF5-SDK\components\ble\nrf_ble_qwr;..\..\library\nRF5-SDK\components\ble\peer_manager;..\..\library\nRF5-SDK\components\libraries;..\..\library\nRF5-SDK\components\libraries\atomic;..\..\library\nRF5-SDK\components\libraries\atomic_fifo;..\..\library\nRF5-SDK\components\libraries\atomic_flags;..\..\library\nRF5-SDK\components\libraries\balloc;..\..\library\nRF5-SDK\components\libraries\bootloader;..\..\library\nRF5-SDK\components\libraries\bootloader\ble_dfu;..\..\library\nRF5-SDK\components\libraries\bootloader\dfu;..\..\library\nRF5-SDK\components\libraries\crc16;..\..\library\nRF5-SDK\components\libraries\delay;..\..\library\nRF5-SDK\components\libraries\experimental_section_vars;..\..\library\nRF5-SDK\components\libraries\fds;..\..\library\nRF5-SDK\components\libraries\fifo;..\..\library\nRF5-SDK\components\libraries\fstorage;..\..\library\nRF5-SDK\components\libraries\gpiote;..\..\library\nRF5-SDK\components\libraries\hardfault;..\..\library\nRF5-SDK\components\libraries\log;..\..\library\nRF5-SDK\components\libraries\log\src;..\..\library\nRF5-SDK\components\libraries\memobj;..\..\library\nRF5-SDK\components\libraries\mutex;..\..\library\nRF5-SDK\components\libraries\pwr_mgmt;..\..\library\nRF5-SDK\components\libraries\scheduler;..\..\library\nRF5-SDK\components\libraries\strerror;..\..\library\nRF5-SDK\components\libraries\svc;..\..\library\nRF5-SDK\components\libraries\timer;..\..\library\nRF5-SDK\components\libraries\util;..\..\library\nRF5-SDK\components\softdevice;..\..\library\nRF5-SDK\components\softdevice\common;..\..\library\nRF5-SDK\components\softdevice\s132;..\..\library\nRF5-SDK\components\softdevice\s132\headers;..\..\library\nRF5-SDK\components\softdevice\s132\headers\nrf52;..\..\library\nRF5-SDK\components\toolchain;..\..\library\nRF5-SDK\external\fprintf;..\..\library\nRF5-SDK\external\segger_rtt;..\..\library\nRF5-SDK\integration;..\..\library\nRF5-SDK\integration\nrfx;..\..\library\nRF5-SDK\modules\nrfx;..\..\library\nRF5-SDK\modules\nrfx\drivers;..\..\library\nRF5-SDK\modules\nrfx\drivers\include;..\..\library\nRF5-SDK\modules\nrfx\hal;..\..\library\nRF5-SDK\modules\nrfx\mdk
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20003638 size 0xc9c8
  link misc: --diag_suppress 6330
  group application
    ../../application/: appfactory.cpp heatflow.cpp heatflow.h uptime.cpp uptime.h eventid.h
  group application-config
    ../../application/config/: assert-config.h battery-config.h ble-advertiser-config.h ble-config.h ble-dfu-config.h ble-gap-config.h ble-gatt-config.h ble-private-service-config.h ble-scheduler-config.h ble-security-config.h ble-services-config.h button-config.h firmware-revision.h flash-config.h gpio-config.h pwm-config.h saadc-config.h sdk-tools-config.h sensor-config.h uicr-config.h watchdoghal-config.h xf-config.h
  group core
    ../../core/: factory.cpp factory.h main.cpp
  group mcu-hal
    ../../library/mcu/common/nrf5/hal/gpio/: gpiohal.cpp gpiohal.h ledhal.cpp ledhal.h
    ../../library/mcu/common/nrf5/hal/uart/: irqlinetouartmaster.cpp irqlinetouartmaster.h
    ../../library/mcu/common/nrf5/hal/saadc/: saadchal.cpp saadchal.h
    ../../library/mcu/common/nrf5/hal/wdt/: watchdoghal.cpp watchdoghal.h
    ../../library/mcu/common/nrf5/hal/pwm/: pwmhal.cpp pwmhal.h
  group mcu-nrf5
    ../../library/mcu/common/nrf5/critical/: critical.c critical.h
    ../../library/mcu/common/nrf5/: mcu.cpp mcu.h
  group mdw-battery
    ../../library/mdw-nrf/common/battery/: batterymanager.cpp batterymanager.h batterymanagerpersistor.h batterystate.h
    ../../library/mdw-nrf/common/battery/interface/: batteryobserver.h
  group mdw-ble
    ../../library/mdw-nrf/common/ble/: advertiser.cpp advertiser.h blecontroller.cpp blecontroller.h gap.cpp gap.h gapparameter.h gatt.cpp gatt.h manufacturerdata.h peripheralcontroller.cpp peripheralcontroller.h peripheralpersistor.h scheduler.cpp scheduler.h security.cpp security.h
    ../../library/mdw-nrf/common/ble/services/: gattcharacteristic.cpp gattcharacteristic.h
  group mdw-ble-observer
    ../../library/mdw-nrf/common/ble/interface/: blegapobserver.h blegattobserver.h bleobserver.h bleprivateserviceobserver.h bleservicesobserver.h peripheralobserver.h
  group mdw-ble-services
    ../../library/mdw-nrf/common/ble/services/: blevendor.cpp blevendor.h privateservice.cpp privateservice.h services.cpp services.h
  group mdw-ble-private-services
    ../../library/mdw-nrf/partners/ble/services/hevs/mhfs/: mhfsdefinition.h mhfsobserver.h mhfsservice.cpp mhfsservice.h
  group mdw-button
    ../../library/mdw-nrf/common/button/: button.cpp button.h buttoncontroller.cpp buttoncontroller.h buttonid.h buttonpersistor.h
    ../../library/mdw-nrf/common/button/interface/: buttonobserver.h
  group mdw-common
    ../../library/mdw-nrf/common/core/: islist.hpp isubject.hpp
  group mdw-flash
    ../../library/mdw-nrf/common/flash/: flashcontroller.cpp flashcontroller.h flashfileid.h
    ../../library/mdw-nrf/common/flash/interface/: flashobserver.h persister.h
  group mdw-gpio
    ../../library/mdw-nrf/common/gpio/: basecontroller.cpp basecontroller.h gpio.cpp gpio.h gpiocontroller.cpp gpiocontroller.h gpioid.h ledcontroller.cpp ledcontroller.h
    ../../library/mdw-nrf/common/gpio/interface/: gpioobserver.h
  group mdw-sensor
    ../../library/mdw/sensor/ads111X/: ads1118.cpp ads1118.h
    ../../library/mdw/sensor/: sensorcontroller.cpp sensorcontroller.h
    ../../library/mdw/sensor/XF/: sensorevent.h
  group mdw-timer
    ../../library/mdw-nrf/common/timer/: timerinstance.h
  group mdw-tools
    ../../library/mcu/common/nrf5/tools/: logtrace.cpp logtrace.h sdktools.cpp sdktools.h
  group nRF_BLE
    ../../library/nRF5-SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../library/nRF5-SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../library/nRF5-SDK/components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../library/nRF5-SDK/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../library/nRF5-SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../library/nRF5-SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_BLE_Services
    ../../library/nRF5-SDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../library/nRF5-SDK/components/ble/ble_services/ble_dis/: ble_dis.c
  group nRF_DFU
    ../../library/nRF5-SDK/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
  group nRF_Drivers
    ../../library/nRF5-SDK/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_pwm.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_timer.c nrfx_twim.c nrfx_wdt.c
    ../../library/nRF5-SDK/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../library/nRF5-SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../library/nRF5-SDK/components/libraries/fifo/: app_fifo.c
    ../../library/nRF5-SDK/components/libraries/scheduler/: app_scheduler.c
    ../../library/nRF5-SDK/components/libraries/timer/: app_timer.c
    ../../library/nRF5-SDK/components/libraries/crc16/: crc16.c
    ../../library/nRF5-SDK/components/libraries/fds/: fds.c
    ../../library/nRF5-SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../library/nRF5-SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../library/nRF5-SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../library/nRF5-SDK/components/libraries/atomic/: nrf_atomic.c
    ../../library/nRF5-SDK/components/libraries/balloc/: nrf_balloc.c
    ../../library/nRF5-SDK/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../library/nRF5-SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../library/nRF5-SDK/components/libraries/memobj/: nrf_memobj.c
    ../../library/nRF5-SDK/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../library/nRF5-SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../library/nRF5-SDK/components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../library/nRF5-SDK/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../library/nRF5-SDK/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_SoftDevice
    ../../library/nRF5-SDK/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_SVC
    ../../library/nRF5-SDK/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group platform
    ../../library/platform/board/: boards.h
    ../../library/platform/heatflow_10/: heatflow_10.h
  group platform-config
    ../../library/platform/heatflow_10/config/: hardware-revision.h memorypool-config.h platform-config.h sdk_config.h
  group pool
    ../../library/mdw-nrf/common/pool/: memorypool.cpp memorypool.h memorypoolmacros.h objectpool.hpp
  group sdk-patch
    ../../library/sdk-patch/: nrf_sdh_ble_ext.h nrf_sdh_soc_ext.h
  group xf
    ../../library/xf/adapters/: xf_nRF5_adapter.cpp xf_adapter.h
    ../../library/xf/core/: initialevent.cpp initialevent.h ixfevent.h ixfreactive.h xf.cpp xf.h xfevent.cpp xfevent.h xfeventstatus.h xfnulltransition.cpp xfnulltransition.h xfreactive.cpp xfreactive.h xfthread.cpp xfthread.h xftimeout.cpp xftimeout.h xftimeoutmanager.cpp xftimeoutmanager.h
    ../../library/xf/queue/: template-queue.h
software components: CMSIS:CORE 5.2.0, Device:Startup 8.24.1
